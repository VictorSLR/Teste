# IAR project Elevador.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: UART_BUFFERED; PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\driverlib; ..\Device\ARM\ARMCM4\Include; ..\CMSIS\RTOS2\Include; ..\CMSIS\RTOS2\RTX\Include; ..\CMSIS\RTOS2\RTX\Library\IAR\IDE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Elevador.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../driverlib/ewarm/Exe/: driverlib.a
    src/: lab3.c RTX_Config.c rtx_lib.c startup_tm4c1294.s system_TM4C1294.c TM4C1294NCPDT.h uartstdio.c
    ../CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
